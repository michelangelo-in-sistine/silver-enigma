# Keil uVision project powermesh_se.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: powermesh_se +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\source;..\..\..\stm32f030_common\CMSIS\device\include;..\..\..\stm32f030_common\CMSIS\include;..\..\..\stm32f030_common\StdPeriph\inc;..\..\..\powermesh_stack\mainstream
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group source
    ../source/: stm32f0xx_it.c _hardware.c main.c _rscodec.c _int_entry.c _userflash.c
    ../../../powermesh_stack/mainstream/: _uart.c _dll.c _general.c _measure.c _mem.c _phy.c _powermesh_timing.c _queue.c _timer.c _addr_db.c _network_misc.c _network_optimization.c _psr_manipulation.c _topology.c _network_management.c _powermesh_management.c _dst.c _ebc.c _mgnt_app.c _psr.c
  group cmsis
    ../../../stm32f030_common/CMSIS/device/: system_stm32f0xx.c startup_stm32f030.s
  group stdperiph
    ../../../stm32f030_common/StdPeriph/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_flash.c
