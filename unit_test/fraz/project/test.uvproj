# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c include: ..\..\..\powermesh_stack\mainstream;..\..\common;..\..\..\..\powermesh_unify\device_cc\trunk\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../: fraz_test.c
    ../../common/: _stm32f10x_it.c test_func.c cortexm3_macro.s stm32f10x_vector.s STM32F103.lib
    ../../../powermesh_stack/mainstream/: _fraz.c
