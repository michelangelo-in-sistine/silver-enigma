# Keil uVision project powermesh_ss.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: powermesh_ss +hex
  c flags: Optimize=9
  c include: ..\source;..\..\..\powermesh_stack\mainstream
  link misc: REMOVEUNUSED
  group Source Group 1
    ../source/: _hardware.c _rscodec.c main.c _nvr.c
    ../../../powermesh_stack/mainstream/: _uart.c _addr_db.c _app.c _app_nvr_data.c _dll.c _dst.c _ebc.c _general.c _measure.c _mem.c _mgnt_app.c _phy.c _powermesh_timing.c _psr.c _queue.c _timer.c _ptp.c _fraz.c
